# Keil uVision project tmp_measure.uvprojx, settings and files
target tmp_measure (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303ZETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.1
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: tmp_measure +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F303xE,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;                                                              ../Drivers/STM32F3xx_HAL_Driver/Inc;                                                              ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;                                                              ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                                                              ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Application/User/Core
    ../Core/Src/: pulsegen.c uart_io.c global_io.c tmp1075.c main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_utils.c stm32f3xx_ll_exti.c stm32f3xx_ll_usb.c stm32f3xx_ll_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_ll_rcc.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_exti.c stm32f3xx_ll_rtc.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_ll_usart.c stm32f3xx_ll_dma.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.3.0
